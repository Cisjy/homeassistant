# Keil uVision project homeassistant20240903174928.uvprojx, settings and files
target homeassistant20240903174928 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: homeassistant20240903174928 +hex
  AfterMake: fromelf --bin -o ".\bin_file\@L.bin" "#L"
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/STM32F1xx_HAL_Driver/Inc;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;..\HardWare\oled;..\Common\delay;..\Common\i2c_c;..\Common\uart_print;..\HardWare\MPU6050\eMPL;..\HardWare\MPU6050;..\HardWare\dht11;..\HardWare\w25qxx;..\Common\cJSON;..\Common\key;..\Common\ymodem;..\HardWare\BH1750;..\HardWare\beep;..\HardWare\esp8266;..\Common\esp8266_test;..\Common\mqtt;..\Common\my_string
  asm include: ../Core/Inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c stm32f1xx_hal_timebase_tim.c hard_init.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_spi.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
  group HardWare
    ../HardWare/oled/: OLED.c OLED_Display.c
    ../HardWare/dht11/: dht11.c
    ../HardWare/w25qxx/: w25qxx.c
    ../HardWare/BH1750/: BH1750.c
    ../HardWare/beep/: beep.c
  group Common
    ../Common/delay/: delay.c
    ../Common/i2c_c/: i2c_c.c
    ../Common/uart_print/: usart_print.c
    ../Common/key/: key.c
    ../Common/ymodem/: common.c ymodem.c
    ../Common/my_string/: my_string.c
    ../Common/esp8266_test/: esp8266_test.c
    ../Common/mqtt/: mqtt.c
  group HardWare/mpu6050
    ../HardWare/MPU6050/: mpu6050.c
    ../HardWare/MPU6050/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
  group HardWare/esp8266
    ../Common/cJSON/: cJSON.c
    ../HardWare/esp8266/: esp8266.c
software components: CMSIS:CORE 4.3.0
